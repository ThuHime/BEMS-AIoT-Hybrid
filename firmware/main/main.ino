/*
 * BEMS AIoT - HYBRID HARDWARE + SIMULATION FIRMWARE
 * ESP32-S3 + one physical PZEM-004T v3.0 + nineteen virtual rooms.
 *
 * DATA DESIGN
 *   Room 01: actual values read from one PZEM-004T v3.0 (UART TTL / Modbus RTU).
 *   Room 02..20: explicitly simulated values generated by the ESP32-S3.
 *   JSON contains simulated:false only for Room 01 and true for Rooms 02..20.
 *
 * IMPORTANT
 *   - There is no RS485/MAX485 and no scan of 20 PZEM addresses in this build.
 *   - There is no physical relay output. MQTT Demand Response only changes the
 *     values of simulated rooms. It never switches an electrical load.
 *   - This sketch only handles the PZEM low-voltage UART data interface. Any
 *     mains-side installation must be handled and checked by a qualified
 *     electrical professional. Do not use this sketch as a mains wiring guide.
 *
 * PIN SELECTION
 *   PZEM TX -> ESP32-S3 GPIO16 (UART RX)
 *   PZEM RX -> ESP32-S3 GPIO17 (UART TX)
 *   PZEM GND <-> ESP32-S3 GND
 *   ESP32-S3 GPIOs are 3.3V logic and are not 5V tolerant. Verify signal levels
 *   and use suitable level translation where required.
 *
 * LIBRARIES (Arduino Library Manager)
 *   - PZEM004Tv30 by Jakub Mandula
 *   - WiFiManager by tzapu
 *   - PubSubClient by Nick O'Leary
 *   - ArduinoJson 6.x by Benoit Blanchon
 *
 * BOARD PACKAGE
 *   - Espressif ESP32 Arduino core 2.x or 3.x
 *
 * MQTT SECURITY
 *   - Local broker: Mosquitto on the Ubuntu Server, TCP port 1883.
 *   - ESP32 user: bems_esp32 (password entered in the provisioning portal).
 *   - Python backend user: bems_backend (configured on the server).
 *   - Anonymous MQTT access is disabled on the broker.
 *   - This local 1883 connection is not encrypted. Keep it on a trusted LAN;
 *     do not expose port 1883 directly to the public Internet. Use a VPN or
 *     configure a properly validated TLS listener for untrusted networks.
 *   - Optional Cloud MQTT stays disabled until a real hostname and Root CA are
 *     configured below.
 */

#include <Arduino.h>
#include <WiFi.h>
#include <WiFiClient.h>
#include <WiFiClientSecure.h>
#include <WiFiManager.h>
#include <PubSubClient.h>
#include <ArduinoJson.h>
#include <Preferences.h>
#include <PZEM004Tv30.h>
#include <time.h>
#include <math.h>
#include <esp_system.h>

// --------------------------- DEVICE CONFIGURATION ----------------------------

static constexpr uint8_t ROOM_COUNT = 20;
static constexpr uint8_t REAL_PZEM_ROOM_ID = 1;
static constexpr int PZEM_RX_PIN = 16;
static constexpr int PZEM_TX_PIN = 17;
static constexpr uint32_t TELEMETRY_INTERVAL_MS = 5000;
static constexpr uint8_t WIFI_RESET_BUTTON_PIN = 0;
static constexpr uint32_t WIFI_RESET_HOLD_MS = 5000;
static constexpr uint32_t SIM_SPIKE_PERIOD_MS = 600000;
static constexpr uint32_t SIM_SPIKE_LENGTH_MS = 20000;
static constexpr float SIM_SHED_REMAINING_LOAD_FACTOR = 0.25f;
static constexpr uint32_t MQTT_RECONNECT_INTERVAL_MS = 5000;
static constexpr uint32_t DEBUG_STATUS_INTERVAL_MS = 10000;
static constexpr size_t TELEMETRY_JSON_CAPACITY = 8192;
static constexpr uint16_t MQTT_PACKET_BUFFER_SIZE = 8192;

// MQTT topics used by the Python backend.
static const char *LOCAL_TELEMETRY_TOPIC = "bems/telemetry";
static const char *LOCAL_COMMAND_TOPIC = "bems/commands/#";
static const char *CLOUD_DEFAULT_TELEMETRY_TOPIC = "bems/telemetry";

// Keep empty to disable optional Cloud MQTT. Never use setInsecure() in deployment.
static const char CLOUD_ROOT_CA_PEM[] PROGMEM = "";

// ------------------------------- GLOBAL OBJECTS ------------------------------

PZEM004Tv30 pzem(Serial2, PZEM_RX_PIN, PZEM_TX_PIN);

Preferences preferences;
WiFiManager wifiManager;
WiFiClient localNetworkClient;
WiFiClientSecure cloudTlsClient;
PubSubClient localMqtt(localNetworkClient);
PubSubClient cloudMqtt(cloudTlsClient);

// ------------------------ PORTAL-EDITABLE SETTINGS ----------------------------

// Local MQTT broker settings. Change the IP if the Ubuntu Server address changes.
char localMqttHost[64] = "192.168.1.14";
char localMqttPort[8] = "1883";
char localMqttUser[96] = "bems_esp32";
char localMqttPassword[128] = "";  // Enter through the phone provisioning portal.

// Optional Cloud MQTT settings. Leave blank for the current single-broker design.
char cloudMqttHost[96] = "";
char cloudMqttPort[8] = "8883";
char cloudMqttUser[96] = "";
char cloudMqttPassword[128] = "";
char cloudMqttTopic[96] = "bems/telemetry";

WiFiManagerParameter *portalLocalHost = nullptr;
WiFiManagerParameter *portalLocalPort = nullptr;
WiFiManagerParameter *portalLocalUser = nullptr;
WiFiManagerParameter *portalLocalPassword = nullptr;
WiFiManagerParameter *portalCloudHost = nullptr;
WiFiManagerParameter *portalCloudPort = nullptr;
WiFiManagerParameter *portalCloudUser = nullptr;
WiFiManagerParameter *portalCloudPassword = nullptr;
WiFiManagerParameter *portalCloudTopic = nullptr;

bool shouldSaveSettings = false;
bool preferencesReady = false;
uint32_t lastTelemetryMs = 0;
uint32_t buttonPressedAtMs = 0;
uint32_t previousSimulationSampleMs = 0;
uint32_t lastLocalMqttAttemptMs = 0;
uint32_t lastCloudMqttAttemptMs = 0;
uint32_t lastWifiDebugMs = 0;
uint32_t lastLoopDebugMs = 0;
float simulatedEnergyKWh[ROOM_COUNT] = {0.0f};
uint32_t virtualShedUntilMs[ROOM_COUNT] = {0};
// Shared static telemetry buffer.
// Avoid allocating an 8 KB array on the loopTask stack.
static char telemetryPayload[TELEMETRY_JSON_CAPACITY];

// ------------------------------ DATA STRUCTURES ------------------------------

struct PzemMeasurement {
  float voltageV = 0.0f;
  float currentA = 0.0f;
  float powerW = 0.0f;
  float energyKWh = 0.0f;
  float powerFactor = 0.0f;
  float frequencyHz = 0.0f;
  bool valid = false;
};

// ------------------------------ HELPER FUNCTIONS -----------------------------

void copyToBuffer(char *destination, size_t destinationSize, const String &value) {
  if (destinationSize == 0) return;
  size_t count = value.length();
  if (count >= destinationSize) count = destinationSize - 1;
  memcpy(destination, value.c_str(), count);
  destination[count] = '\0';
}

void loadBrokerSettings() {
  preferencesReady = preferences.begin("bems-hybrid", false);
  if (!preferencesReady) {
    Serial.println("ERROR: Could not open Preferences namespace; using compiled defaults.");
    return;
  }

  copyToBuffer(localMqttHost, sizeof(localMqttHost),
               preferences.getString("localHost", localMqttHost));
  copyToBuffer(localMqttPort, sizeof(localMqttPort),
               preferences.getString("localPort", localMqttPort));
  copyToBuffer(localMqttUser, sizeof(localMqttUser),
               preferences.getString("localUser", localMqttUser));
  copyToBuffer(localMqttPassword, sizeof(localMqttPassword),
               preferences.getString("localPass", localMqttPassword));

  copyToBuffer(cloudMqttHost, sizeof(cloudMqttHost),
               preferences.getString("cloudHost", cloudMqttHost));
  copyToBuffer(cloudMqttPort, sizeof(cloudMqttPort),
               preferences.getString("cloudPort", cloudMqttPort));
  copyToBuffer(cloudMqttUser, sizeof(cloudMqttUser),
               preferences.getString("cloudUser", cloudMqttUser));
  copyToBuffer(cloudMqttPassword, sizeof(cloudMqttPassword),
               preferences.getString("cloudPass", cloudMqttPassword));
  copyToBuffer(cloudMqttTopic, sizeof(cloudMqttTopic),
               preferences.getString("cloudTopic", cloudMqttTopic));
}

void saveBrokerSettings() {
  if (!preferencesReady) {
    Serial.println("ERROR: Preferences unavailable; broker settings were not saved.");
    return;
  }

  preferences.putString("localHost", localMqttHost);
  preferences.putString("localPort", localMqttPort);
  preferences.putString("localUser", localMqttUser);
  preferences.putString("localPass", localMqttPassword);
  preferences.putString("cloudHost", cloudMqttHost);
  preferences.putString("cloudPort", cloudMqttPort);
  preferences.putString("cloudUser", cloudMqttUser);
  preferences.putString("cloudPass", cloudMqttPassword);
  preferences.putString("cloudTopic", cloudMqttTopic);

  Serial.println("Broker settings saved to ESP32 NVS (password not displayed).");
}

void buildProvisioningPortal() {
  portalLocalHost = new WiFiManagerParameter(
      "local_host", "Local MQTT host / Ubuntu Server LAN IP",
      localMqttHost, sizeof(localMqttHost));
  portalLocalPort = new WiFiManagerParameter(
      "local_port", "Local MQTT port", localMqttPort, sizeof(localMqttPort));
  portalLocalUser = new WiFiManagerParameter(
      "local_user", "Local MQTT username", localMqttUser, sizeof(localMqttUser));
  portalLocalPassword = new WiFiManagerParameter(
      "local_pass", "Local MQTT password", localMqttPassword,
      sizeof(localMqttPassword), "type='password' autocomplete='new-password'");

  portalCloudHost = new WiFiManagerParameter(
      "cloud_host", "Cloud MQTT hostname (optional)", cloudMqttHost, sizeof(cloudMqttHost));
  portalCloudPort = new WiFiManagerParameter(
      "cloud_port", "Cloud MQTT TLS port", cloudMqttPort, sizeof(cloudMqttPort));
  portalCloudUser = new WiFiManagerParameter(
      "cloud_user", "Cloud MQTT username / device token", cloudMqttUser, sizeof(cloudMqttUser));
  portalCloudPassword = new WiFiManagerParameter(
      "cloud_pass", "Cloud MQTT password (optional)", cloudMqttPassword,
      sizeof(cloudMqttPassword), "type='password' autocomplete='new-password'");
  portalCloudTopic = new WiFiManagerParameter(
      "cloud_topic", "Cloud telemetry topic", cloudMqttTopic, sizeof(cloudMqttTopic));

  wifiManager.addParameter(portalLocalHost);
  wifiManager.addParameter(portalLocalPort);
  wifiManager.addParameter(portalLocalUser);
  wifiManager.addParameter(portalLocalPassword);
  wifiManager.addParameter(portalCloudHost);
  wifiManager.addParameter(portalCloudPort);
  wifiManager.addParameter(portalCloudUser);
  wifiManager.addParameter(portalCloudPassword);
  wifiManager.addParameter(portalCloudTopic);

  wifiManager.setSaveConfigCallback([]() { shouldSaveSettings = true; });
  wifiManager.setConfigPortalTimeout(0);
}

void capturePortalValues() {
  if (portalLocalHost) {
    copyToBuffer(localMqttHost, sizeof(localMqttHost), portalLocalHost->getValue());
  }
  if (portalLocalPort) {
    copyToBuffer(localMqttPort, sizeof(localMqttPort), portalLocalPort->getValue());
  }
  if (portalLocalUser) {
    copyToBuffer(localMqttUser, sizeof(localMqttUser), portalLocalUser->getValue());
  }
  if (portalLocalPassword) {
    const String submittedPassword = portalLocalPassword->getValue();
    // Some browser password fields submit an empty value unless the user enters
    // it again. Do not overwrite a previously saved password with an empty one.
    if (submittedPassword.length() > 0) {
      copyToBuffer(localMqttPassword, sizeof(localMqttPassword), submittedPassword);
    }
  }
  if (portalCloudHost) {
    copyToBuffer(cloudMqttHost, sizeof(cloudMqttHost), portalCloudHost->getValue());
  }
  if (portalCloudPort) {
    copyToBuffer(cloudMqttPort, sizeof(cloudMqttPort), portalCloudPort->getValue());
  }
  if (portalCloudUser) {
    copyToBuffer(cloudMqttUser, sizeof(cloudMqttUser), portalCloudUser->getValue());
  }
  if (portalCloudPassword) {
    const String submittedCloudPassword = portalCloudPassword->getValue();
    if (submittedCloudPassword.length() > 0) {
      copyToBuffer(cloudMqttPassword, sizeof(cloudMqttPassword), submittedCloudPassword);
    }
  }
  if (portalCloudTopic) {
    copyToBuffer(cloudMqttTopic, sizeof(cloudMqttTopic), portalCloudTopic->getValue());
  }

  if (shouldSaveSettings) {
    saveBrokerSettings();
    shouldSaveSettings = false;
  }

  Serial.printf("Local MQTT host: %s:%s | username: %s | password: %s\n",
                localMqttHost, localMqttPort, localMqttUser,
                strlen(localMqttPassword) > 0 ? "configured" : "MISSING");
}

void connectWiFiWithPhonePortal() {
  char setupPassword[11];
  const char alphabet[] = "ABCDEFGHJKLMNPQRSTUVWXYZabcdefghijkmnopqrstuvwxyz23456789";
  for (size_t i = 0; i < sizeof(setupPassword) - 1; ++i) {
    setupPassword[i] = alphabet[esp_random() % (sizeof(alphabet) - 1)];
  }
  setupPassword[sizeof(setupPassword) - 1] = '\0';
  Serial.printf("Setup AP: BEMS-ESP32S3 | password: %s\n", setupPassword);

  buildProvisioningPortal();
  const bool connected = wifiManager.autoConnect("BEMS-ESP32S3", setupPassword);
  if (!connected) {
    Serial.println("Wi-Fi setup did not finish. Restarting device.");
    delay(1000);
    ESP.restart();
  }

  capturePortalValues();
  Serial.print("Wi-Fi connected. ESP32-S3 IP: ");
  Serial.println(WiFi.localIP());
}

void configureVietnamTime() {
  configTzTime("ICT-7", "pool.ntp.org", "time.google.com");
}

String makeMqttClientId(const char *prefix) {
  const uint64_t mac = ESP.getEfuseMac();
  char result[48];
  snprintf(result, sizeof(result), "%s-%04X%08X", prefix,
           (uint16_t)(mac >> 32), (uint32_t)mac);
  return String(result);
}

// ------------------------------- MQTT SETUP ----------------------------------

void onMqttMessage(char *topic, byte *payload, unsigned int length);

void configureMqttClients() {
  localMqtt.setServer(localMqttHost, (uint16_t)atoi(localMqttPort));
  localMqtt.setCallback(onMqttMessage);
  if (!localMqtt.setBufferSize(MQTT_PACKET_BUFFER_SIZE)) {
    Serial.println("WARNING: Could not set local MQTT buffer to 8192 bytes.");
  }
  localMqtt.setKeepAlive(30);
  localMqtt.setSocketTimeout(5);

  if (strlen(cloudMqttHost) > 0 && strlen(CLOUD_ROOT_CA_PEM) > 100) {
    cloudTlsClient.setCACert(CLOUD_ROOT_CA_PEM);
    cloudMqtt.setServer(cloudMqttHost, (uint16_t)atoi(cloudMqttPort));
    cloudMqtt.setCallback(onMqttMessage);
    if (!cloudMqtt.setBufferSize(MQTT_PACKET_BUFFER_SIZE)) {
      Serial.println("WARNING: Could not set cloud MQTT buffer to 8192 bytes.");
    }
    cloudMqtt.setKeepAlive(30);
    cloudMqtt.setSocketTimeout(5);
  } else {
    Serial.println("Cloud MQTT disabled until hostname and Root CA are configured.");
  }
}

void connectLocalMqtt() {
  if (localMqtt.connected()) return;

  if (strlen(localMqttHost) == 0 || strlen(localMqttPort) == 0) {
    Serial.println("Local MQTT host/port missing. Check provisioning settings.");
    return;
  }
  if (strlen(localMqttUser) == 0 || strlen(localMqttPassword) == 0) {
    Serial.println("Local MQTT credentials missing. Please configure username/password.");
    return;
  }

  const String clientId = makeMqttClientId("bems-local");
  const bool connected = localMqtt.connect(
      clientId.c_str(), localMqttUser, localMqttPassword);

  if (connected) {
    const bool subscribed = localMqtt.subscribe(LOCAL_COMMAND_TOPIC);
    Serial.println("Local MQTT connected with authentication.");
    Serial.printf("Command topic subscription: %s\n", subscribed ? "success" : "FAILED");
  } else {
    Serial.printf("Local MQTT connection failed, state=%d, host=%s, port=%s\n",
                  localMqtt.state(), localMqttHost, localMqttPort);
  }
}

void connectCloudMqtt() {
  if (cloudMqtt.connected()) return;
  if (strlen(cloudMqttHost) == 0 || strlen(CLOUD_ROOT_CA_PEM) <= 100) return;

  const String clientId = makeMqttClientId("bems-cloud");
  const bool connected = cloudMqtt.connect(
      clientId.c_str(), cloudMqttUser, cloudMqttPassword);

  if (connected) {
    cloudMqtt.subscribe(LOCAL_COMMAND_TOPIC);
    Serial.println("Cloud MQTT connected with TLS verification.");
  } else {
    Serial.printf("Cloud MQTT connection failed, state=%d\n", cloudMqtt.state());
  }
}

// ---------------------------- PZEM DATA READING ------------------------------

PzemMeasurement readPhysicalPzem() {
  PzemMeasurement result;
  const float voltage = pzem.voltage();
  const float current = pzem.current();
  const float power = pzem.power();
  const float energy = pzem.energy();
  const float frequency = pzem.frequency();
  const float powerFactor = pzem.pf();

  const bool allRegistersFinite = isfinite(voltage) && isfinite(current) &&
                                  isfinite(power) && isfinite(energy) &&
                                  isfinite(frequency) && isfinite(powerFactor);
  const bool plausibleVoltage = (voltage >= 80.0f && voltage <= 260.0f);
  const bool plausibleFrequency = (frequency >= 45.0f && frequency <= 65.0f);
  const bool plausiblePowerFactor = (powerFactor >= 0.0f && powerFactor <= 1.0f);

  result.valid = allRegistersFinite && plausibleVoltage && plausibleFrequency &&
                 plausiblePowerFactor && current >= 0.0f && power >= 0.0f &&
                 energy >= 0.0f;

  if (result.valid) {
    result.voltageV = voltage;
    result.currentA = current;
    result.powerW = power;
    result.energyKWh = energy;
    result.frequencyHz = frequency;
    result.powerFactor = powerFactor;
  }
  return result;
}

// ------------------------- NINETEEN VIRTUAL ROOMS ----------------------------

float randomUnit() {
  return (float)esp_random() / 4294967296.0f;
}

float makeVirtualRoomPowerW(uint8_t roomId, uint32_t nowMs, float voltageV) {
  const uint8_t virtualIndex = roomId - 2;
  const float elapsedSeconds = (float)nowMs / 1000.0f;
  const float basePowerW = 110.0f + (float)virtualIndex * 34.0f;

  float occupancyFactor = 0.70f;
  if (time(nullptr) > 1700000000) {
    struct tm localClock;
    const time_t now = time(nullptr);
    localtime_r(&now, &localClock);
    occupancyFactor = (localClock.tm_hour >= 7 && localClock.tm_hour < 19) ? 1.0f : 0.45f;
  }

  const float dailyCurve = 1.0f + 0.14f * sinf(
      (elapsedSeconds / 86400.0f) * 6.2831853f + virtualIndex * 0.31f);
  const float shortNoise = (randomUnit() - 0.5f) * 16.0f;
  float powerW = basePowerW * occupancyFactor * dailyCurve + shortNoise;

  // This is a deliberately simulated event, not a real electrical fault.
  if (roomId == 20 && (nowMs % SIM_SPIKE_PERIOD_MS) < SIM_SPIKE_LENGTH_MS) {
    powerW += 1700.0f;
  }

  const uint32_t shedExpiry = virtualShedUntilMs[roomId - 1];
  if (shedExpiry != 0 && (int32_t)(shedExpiry - nowMs) > 0) {
    powerW *= SIM_SHED_REMAINING_LOAD_FACTOR;
  } else {
    virtualShedUntilMs[roomId - 1] = 0;
  }

  (void)voltageV;
  return powerW < 0.0f ? 0.0f : powerW;
}

// --------------------------- JSON TELEMETRY ----------------------------------

void addPzemRoom(JsonArray rooms, const PzemMeasurement &measurement) {
  JsonObject room = rooms.createNestedObject();
  room["id"] = REAL_PZEM_ROOM_ID;
  room["room_name"] = "Room 01 - PZEM";
  room["source"] = "pzem004t_v3";
  room["simulated"] = false;
  room["valid"] = measurement.valid;
  room["voltage_v"] = measurement.voltageV;
  room["current_a"] = measurement.currentA;
  room["power_w"] = measurement.powerW;
  room["energy_kwh"] = measurement.energyKWh;
  room["power_factor"] = measurement.powerFactor;
  room["frequency_hz"] = measurement.frequencyHz;
}

void addVirtualRooms(JsonArray rooms, uint32_t nowMs, uint32_t elapsedMs) {
  const float voltageV = 230.0f + 1.2f * sinf((float)nowMs / 45000.0f);
  const float elapsedHours = (float)elapsedMs / 3600000.0f;

  for (uint8_t roomId = 2; roomId <= ROOM_COUNT; ++roomId) {
    const float powerW = makeVirtualRoomPowerW(roomId, nowMs, voltageV);
    const float powerFactor = 0.88f + 0.08f * ((float)((roomId - 2) % 5) / 4.0f);
    const float currentA = powerW / (voltageV * powerFactor);

    simulatedEnergyKWh[roomId - 1] += (powerW / 1000.0f) * elapsedHours;

    JsonObject room = rooms.createNestedObject();
    room["id"] = roomId;

    char roomName[40];
    snprintf(roomName, sizeof(roomName), "Room %02u - simulated", (unsigned)roomId);
    room["room_name"] = static_cast<const char *>(roomName);

    room["source"] = "synthetic_generator";
    room["simulated"] = true;
    room["valid"] = true;
    room["voltage_v"] = voltageV;
    room["current_a"] = currentA;
    room["power_w"] = powerW;
    room["energy_kwh"] = simulatedEnergyKWh[roomId - 1];
    room["power_factor"] = powerFactor;
    room["frequency_hz"] = 50.0f;
    room["virtual_load_shed"] =
        (virtualShedUntilMs[roomId - 1] != 0 &&
         (int32_t)(virtualShedUntilMs[roomId - 1] - nowMs) > 0);
  }
}

bool buildTelemetryJson(char *output, size_t outputSize, size_t &writtenBytes) {
  writtenBytes = 0;

  if (output == nullptr || outputSize == 0) {
    Serial.println("[ERROR] Invalid JSON output buffer.");
    return false;
  }
  output[0] = '\0';

  // Reuse the document to avoid repeated heap allocation every telemetry cycle.
  // DynamicJsonDocument stores its pool on the heap, not in the loopTask stack.
  static DynamicJsonDocument document(8192);
  if (document.capacity() < 8192) {
    Serial.printf("[ERROR] Could not allocate JSON document: capacity=%u bytes\n",
                  (unsigned)document.capacity());
    return false;
  }
  document.clear();

  const uint32_t nowMs = millis();
  const time_t epochSeconds = time(nullptr);
  const uint32_t elapsedMs = (previousSimulationSampleMs == 0)
                                 ? 0
                                 : nowMs - previousSimulationSampleMs;

  document["device_id"] = "esp32s3-bems-hybrid-01";
  document["firmware"] = "bems-hybrid-1.0.1";
  document["data_mode"] = "hybrid_one_real_nineteen_simulated";
  document["physical_pzem_count"] = 1;
  document["simulated_room_count"] = 19;
  document["timestamp_epoch_ms"] =
      (epochSeconds > 1700000000)
          ? (uint64_t)epochSeconds * 1000ULL
          : 0ULL;
  document["uptime_ms"] = nowMs;
  // Device connection metadata for the BEMS Portal top status strip.
  // The ESP32 creates this temporary setup AP only for WiFiManager provisioning.
  // After credentials are entered from a phone, the ESP32 joins the selected Wi-Fi as a station.
  const bool wifiConnected = (WiFi.status() == WL_CONNECTED);
  const bool ntpSynced = (epochSeconds > 1700000000);
  char deviceLocalTime[24] = "NTP_NOT_SYNCED";
  if (ntpSynced) {
    struct tm localInfo;
    if (localtime_r(&epochSeconds, &localInfo) != nullptr) {
      strftime(deviceLocalTime, sizeof(deviceLocalTime), "%Y-%m-%d %H:%M:%S", &localInfo);
    }
  }
  document["wifi_connected"] = wifiConnected;
  document["wifi_ssid"] = wifiConnected ? WiFi.SSID() : "";
  document["wifi_ip"] = wifiConnected ? WiFi.localIP().toString() : "";
  document["wifi_rssi_dbm"] = wifiConnected ? WiFi.RSSI() : 0;
  document["wifi_ntp_synced"] = ntpSynced;
  document["device_local_time"] = deviceLocalTime;
  document["wifi_setup_ap_ssid"] = "BEMS-ESP32S3";
  document["wifi_provisioning_method"] = "WiFiManager temporary setup AP configured from phone";


  JsonArray rooms = document.createNestedArray("rooms");
  if (rooms.isNull()) {
    Serial.println("[ERROR] Could not allocate JSON rooms array.");
    return false;
  }

  const PzemMeasurement physicalReading = readPhysicalPzem();
  addPzemRoom(rooms, physicalReading);
  addVirtualRooms(rooms, nowMs, elapsedMs);

  if (document.overflowed()) {
    Serial.println("[ERROR] ArduinoJson document overflow.");
    return false;
  }

  const size_t requiredBytes = measureJson(document);
  if (requiredBytes == 0 || requiredBytes >= outputSize) {
    Serial.printf("[ERROR] JSON output buffer too small. Required=%u, available=%u\n",
                  (unsigned)requiredBytes, (unsigned)outputSize);
    return false;
  }

  const size_t actualBytes = serializeJson(document, output, outputSize);
  if (actualBytes != requiredBytes) {
    Serial.printf("[ERROR] JSON serialization mismatch. Expected=%u, actual=%u\n",
                  (unsigned)requiredBytes, (unsigned)actualBytes);
    output[0] = '\0';
    return false;
  }

  writtenBytes = actualBytes;
  previousSimulationSampleMs = nowMs;

  Serial.printf("PZEM Room 01: %s | %.1f V | %.3f A | %.1f W | %.3f kWh\n",
                physicalReading.valid ? "VALID" : "NO DATA",
                physicalReading.voltageV,
                physicalReading.currentA,
                physicalReading.powerW,
                physicalReading.energyKWh);
  return true;
}

void publishTelemetry() {
  Serial.println("[DEBUG] Entering publishTelemetry().");

  if (WiFi.status() != WL_CONNECTED) {
    Serial.println("[ERROR] Wi-Fi disconnected; telemetry skipped.");
    return;
  }

  const bool localConnected = localMqtt.connected();
  const bool cloudConnected = cloudMqtt.connected();
  if (!localConnected && !cloudConnected) {
    Serial.println("[ERROR] No MQTT broker connected; telemetry skipped.");
    return;
  }

  size_t payloadLength = 0;
  Serial.println("[DEBUG] Building telemetry JSON...");

  const bool jsonBuilt = buildTelemetryJson(
      telemetryPayload,
      sizeof(telemetryPayload),
      payloadLength);

  if (!jsonBuilt || payloadLength == 0) {
    Serial.println("[ERROR] Failed to build telemetry JSON.");
    return;
  }

  Serial.printf("[DEBUG] JSON generated successfully: %u bytes | Free heap: %u bytes\n",
                (unsigned)payloadLength,
                (unsigned)ESP.getFreeHeap());

  bool localPublished = false;
  bool cloudPublished = false;

  if (localConnected) {
    const size_t localPacketEstimate = payloadLength + strlen(LOCAL_TELEMETRY_TOPIC) + 7;
    if (localPacketEstimate > MQTT_PACKET_BUFFER_SIZE) {
      Serial.printf("[ERROR] Local MQTT packet too large: %u bytes (buffer %u).\n",
                    (unsigned)localPacketEstimate,
                    (unsigned)MQTT_PACKET_BUFFER_SIZE);
    } else {
      localPublished = localMqtt.publish(
          LOCAL_TELEMETRY_TOPIC,
          (const uint8_t *)telemetryPayload,
          (unsigned int)payloadLength,
          false);
    }
  }

  if (cloudConnected) {
    const size_t cloudPacketEstimate = payloadLength + strlen(cloudMqttTopic) + 7;
    if (cloudPacketEstimate > MQTT_PACKET_BUFFER_SIZE) {
      Serial.printf("[ERROR] Cloud MQTT packet too large: %u bytes (buffer %u).\n",
                    (unsigned)cloudPacketEstimate,
                    (unsigned)MQTT_PACKET_BUFFER_SIZE);
    } else {
      cloudPublished = cloudMqtt.publish(
          cloudMqttTopic,
          (const uint8_t *)telemetryPayload,
          (unsigned int)payloadLength,
          false);
    }
  }

  Serial.printf("JSON %u bytes | Local MQTT=%s | Cloud MQTT=%s\n",
                (unsigned)payloadLength,
                localPublished ? "sent" : "not sent",
                cloudPublished ? "sent" : "not sent");
  Serial.printf("[MEMORY] Free heap=%u bytes | Minimum free heap=%u bytes\n",
                (unsigned)ESP.getFreeHeap(),
                (unsigned)ESP.getMinFreeHeap());
  Serial.println("[DEBUG] publishTelemetry() completed.");
}

// --------------------------- MQTT COMMAND HANDLER ----------------------------

void onMqttMessage(char *topic, byte *payload, unsigned int length) {
  DynamicJsonDocument command(512);
  const DeserializationError error = deserializeJson(command, payload, length);
  if (error) {
    Serial.printf("Ignored malformed MQTT command: %s\n", error.c_str());
    return;
  }

  const char *action = command["action"] | "";
  const int roomId = command["room_id"] | -1;
  const bool dryRun = command["dry_run"] | false;

  if (!dryRun) {
    Serial.println("Rejected MQTT command: dry_run must be true.");
    return;
  }
  if (roomId < 2 || roomId > ROOM_COUNT) {
    Serial.println("Rejected MQTT command: only virtual Rooms 02..20 are eligible.");
    return;
  }

  if (strcmp(action, "SIMULATE_SHED_REQUEST") == 0) {
    uint32_t durationMinutes = command["duration_minutes"] | 15;
    if (durationMinutes < 1) durationMinutes = 1;
    if (durationMinutes > 60) durationMinutes = 60;
    virtualShedUntilMs[roomId - 1] = millis() + durationMinutes * 60000UL;
    Serial.printf("DR SIMULATION: Room %02d virtual load reduced for %lu minutes.\n",
                  roomId, (unsigned long)durationMinutes);
  } else if (strcmp(action, "SIMULATE_RESTORE") == 0) {
    virtualShedUntilMs[roomId - 1] = 0;
    Serial.printf("DR SIMULATION: Room %02d virtual load restored.\n", roomId);
  } else {
    Serial.printf("Ignored unsupported action '%s' on %s.\n", action, topic);
  }
}

// ---------------------------- WIFI RESET BUTTON ------------------------------

void serviceWiFiResetButton() {
  // Hold BOOT only after the board has fully started. Holding while powering on
  // can put some ESP32-S3 boards into ROM download mode.
  const bool pressed = (digitalRead(WIFI_RESET_BUTTON_PIN) == LOW);
  if (pressed && buttonPressedAtMs == 0) buttonPressedAtMs = millis();
  if (!pressed) buttonPressedAtMs = 0;

  if (pressed && buttonPressedAtMs != 0 &&
      millis() - buttonPressedAtMs >= WIFI_RESET_HOLD_MS) {
    Serial.println("Erasing saved Wi-Fi and broker values, then restarting...");
    wifiManager.resetSettings();
    if (preferencesReady) {
      preferences.clear();
    }
    delay(500);
    ESP.restart();
  }
}

// --------------------------------- SETUP --------------------------------------

void setup() {
  Serial.begin(115200);
  delay(300);
  pinMode(WIFI_RESET_BUTTON_PIN, INPUT_PULLUP);

  Serial.println();
  Serial.println("BEMS ESP32-S3 HYBRID: 1 REAL PZEM + 19 SIMULATED ROOMS");
  Serial.println("UART: Serial2, RX=GPIO16, TX=GPIO17, 9600 baud, 8N1.");
  Serial.println("No RS485. No physical relay actuation.");

  loadBrokerSettings();
  connectWiFiWithPhonePortal();
  configureVietnamTime();
  configureMqttClients();

  if (strlen(localMqttPassword) == 0) {
    Serial.println("WARNING: Local MQTT password is empty. Open provisioning portal and configure it.");
  }

  previousSimulationSampleMs = millis();
  lastTelemetryMs = millis();
  lastLocalMqttAttemptMs = 0;
  lastCloudMqttAttemptMs = 0;
  Serial.println("Setup completed. Telemetry interval: 5000 ms.");
}

// ---------------------------------- LOOP --------------------------------------

void loop() {
  serviceWiFiResetButton();
  const uint32_t nowMs = millis();

  if (WiFi.status() != WL_CONNECTED) {
    if (nowMs - lastWifiDebugMs >= DEBUG_STATUS_INTERVAL_MS) {
      lastWifiDebugMs = nowMs;
      Serial.printf("[DEBUG] Wi-Fi disconnected; status=%d. Reconnecting...\n", WiFi.status());
    }
    WiFi.reconnect();
    delay(50);
    return;
  }

  // Retry MQTT connection at a controlled interval to avoid flooding the broker.
  if (!localMqtt.connected() &&
      (lastLocalMqttAttemptMs == 0 ||
       nowMs - lastLocalMqttAttemptMs >= MQTT_RECONNECT_INTERVAL_MS)) {
    lastLocalMqttAttemptMs = nowMs;
    connectLocalMqtt();
  }

  if (strlen(cloudMqttHost) > 0 && strlen(CLOUD_ROOT_CA_PEM) > 100 &&
      !cloudMqtt.connected() &&
      (lastCloudMqttAttemptMs == 0 ||
       nowMs - lastCloudMqttAttemptMs >= MQTT_RECONNECT_INTERVAL_MS)) {
    lastCloudMqttAttemptMs = nowMs;
    connectCloudMqtt();
  }

  if (localMqtt.connected()) localMqtt.loop();
  if (cloudMqtt.connected()) cloudMqtt.loop();

  if (nowMs - lastTelemetryMs >= TELEMETRY_INTERVAL_MS) {
    lastTelemetryMs = nowMs;
    Serial.println("[DEBUG] Telemetry timer reached.");
    publishTelemetry();
    Serial.println("[DEBUG] publishTelemetry() completed.");
  }

  if (nowMs - lastLoopDebugMs >= DEBUG_STATUS_INTERVAL_MS) {
    lastLoopDebugMs = nowMs;
    Serial.printf("[STATUS] WiFi=connected | Local MQTT=%s | uptime=%lu s\n",
                  localMqtt.connected() ? "connected" : "disconnected",
                  (unsigned long)(nowMs / 1000UL));
  }

  delay(5);
}
